# Keil uVision project rtx5_demo.uvprojx, settings and files
target demo (6130001::V6.13.1::.\ARMCLANG)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtx5_demo
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\driver\inc;..\mcu\common;..\application;..\midware\SEGGER_RTT_V680a\RTT;..\midware\letter-shell-master\src;..\midware\letter-shell-master\extensions\log;..\midware\littlefs-2.2.1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ../application/: main.c inno_shell.c
  group common
    ../mcu/common/: interrupts_hc32l19x.c
  group driver
    ../driver/src/: ddl.c sysctrl.c gpio.c uart.c flash.c
  group shell
    ../midware/letter-shell-master/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_cfg.h
    ../midware/letter-shell-master/extensions/log/: log.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 1.0.0
